# Keil uVision project Ampermeter f030f4 v1.1.uvprojx, settings and files
target Ampermeter f030f4 v1.1 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Ampermeter f030f4 v1.1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F030
  c include: ..\STM32F0xx_StdPeriph_Driver\inc;..\User;..\User\Fonts;..\User\My_fonts
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group STM32F10x_StdPeriph_Driver
    ../STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_spi.c stm32f0xx_usart.c stm32f0xx_misc.c stm32f0xx_i2c.c stm32f0xx_syscfg.c
  group User
    ../User/: init.c led_module.c main.c stm32f0xx_it.c workspace.c 74hc595_7segments.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.5.0
